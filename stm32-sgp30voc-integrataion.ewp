# IAR project stm32-sgp30voc-integrataion.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE
  ICCARM.CCIncludePath2: drivers\STM32F4xx_HAL_Driver\Inc; drivers\STM32F4xx_HAL_Driver\Inc\Legacy; drivers\CMSIS\Include; drivers\CMSIS\Device\ST\STM32F4xx\Include; application; embedded-sgp\embedded-common; embedded-sgp\sgp30; embedded-sgp\sgp-common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: freertos-examples.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\linker\stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    application/: main.c stm32f4xx_it.c
  group drivers/cmsis
    drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f411xe.s
    drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group drivers/stm32
    drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
  group sgp30
    embedded-sgp/embedded-common/: sensirion_common.c
    sgp30/: sensirion_hw_i2c_implementation.c
    embedded-sgp/sgp30/: sgp30.c
